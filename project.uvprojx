# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M4AF3CFP Renesas
  pack: Renesas.RA_DFP.3.8.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: packages\ali-iotkit-v3.0.1\iotkit-embedded\src\infra;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\mqtt\impl;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\mqtt;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model\client;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_model\server;packages\ali-iotkit-v3.0.1\iotkit-embedded\src\dev_sign;packages\ali-iotkit-v3.0.1\iotkit-embedded\wrappers;applications;.;packages\cJSON-latest;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\dfs\include;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\net\lwip\lwip-2.0.3\src\netif\ppp;rt-thread\components\net\lwip\port;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;packages\ppp_device-v1.1.0\inc;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket
  library: MicroLIB
  scatter file: .\script\fsp.scat
  group ali-iotkit
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/infra/: infra_compat.c infra_string.c infra_timer.c infra_log.c infra_report.c infra_sha256.c infra_net.c infra_cjson.c infra_defs.c infra_prt_nwk_payload.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_model/: dm_cota.c dm_message.c dm_utils.c dm_ipc.c dm_api.c dm_fota.c iotx_cm_mqtt.c dm_message_cache.c impl_linkkit.c dm_log_report.c iotx_cm.c dm_ota.c dm_msg_process.c dm_opt.c dm_manager.c
    packages/ali-iotkit-v3.0.1/ports/rtthread/: HAL_UDP_rtthread.c HAL_TCP_rtthread.c HAL_OS_rtthread.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/mqtt/: mqtt_api.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/mqtt/impl/: MQTTConnectClient.c MQTTUnsubscribeClient.c MQTTSubscribeClient.c MQTTSerializePublish.c iotx_mqtt_client.c MQTTDeserializePublish.c MQTTPacket.c
    packages/ali-iotkit-v3.0.1/ports/: wrapper.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_model/client/: dm_client_adapter.c dm_client.c
    packages/ali-iotkit-v3.0.1/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
  group Applications
    applications/: linkkit_example_solo.c
  group cJSON
    packages/cJSON-latest/: cJSON.c cJSON_Utils.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group ppp_device
    packages/ppp_device-v1.1.0/samples/: ppp_sample.c
    packages/ppp_device-v1.1.0/class/: ppp_device_ec20.c
    packages/ppp_device-v1.1.0/src/: ppp_device.c ppp_netif.c ppp_chat.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
